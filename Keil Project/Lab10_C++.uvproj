# Keil uVision project Lab10_C++.uvproj, settings and files
target Lab 10 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab10_C++
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.cpp DAC.cpp PLL.cpp random.cpp ST7735.cpp Sound.cpp Timer0.cpp Timer1.cpp UART.cpp FIFO.cpp Controller.cpp ADC.cpp DAC.hpp Sound.hpp Joystick.cpp Joystick.hpp frameProcessing.cpp Kentec.cpp tankPhysics.cpp Collision.cpp systick.c
